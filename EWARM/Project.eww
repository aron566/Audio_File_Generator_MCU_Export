<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Audio_Export_Tool.ewp</path>
  </project>
  <batchBuild />
</workspace>
